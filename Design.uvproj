# Keil uVision project Design.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Design
  c flags: Optimize=8 SizeSpeed=1
  group Source File
    ./: STARTUP.A51 ds18b20.c lcm16x2.c main.c song.c
  group Header File
    ./: configuration.h DS18B20.h LCM16X2.h led.h song.h
